Commit message: benchmark stuff

File: cob_gazebo_objects/objects/column.urdf (robot description, URDF)
Before this commit: robot column, 1 links, 0 joints
Links:
- link link: geometry collision cylinder length=1.0 radius=0.5; visual cylinder length=1.0 radius=0.5
